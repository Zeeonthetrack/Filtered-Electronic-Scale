# Keil uVision project SC32F12TS8_ElectronicScale.uvprojx, settings and files
target SC32F12TS8_ElectronicScale (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F12TS8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SC32F12TS8_ElectronicScale +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f12xx,PrintfEable
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS;..\SOC_DebugTouchKey_Lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
    ../SOC_DebugTouchKey_Lib/: SC32F12XX_DynamicDebug_V0.1.lib
  group Drivers
    ../Drivers/TKDriver/C/: sc32f12xx_HighSensitive_lib_T2_V0.1.LIB TKDriver.C
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_op.c sc32f1xxx_adc.c sc32f1xxx_uart.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f12xx.s
